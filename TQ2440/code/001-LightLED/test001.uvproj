# Keil uVision project test001.uvproj, settings and files
target led (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: test001 +hex
  AfterMake: fromelf.exe --bin -o @p.bin Objects/@p.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT1: ROM 0x30000000 size 0x200000
  memory RVCT6: RAM 0x30200000 size 0x200000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group main
    ./: main.c
  group start
    ./: s3c2440.s
